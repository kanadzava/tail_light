# Keil uVision project taillight.uvproj, settings and files
target taillight (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: I2C_M +hex
  c flags: SizeSpeed=1
  c define: FOSC_10000
  c include: Common;Include;.\Code\header
  group Source
    ./Code/: main.c
    ./Code/src/: Init.c Button_debounce.c functions.c
  group Startup
    code/Startup/: STARTUP.A51
